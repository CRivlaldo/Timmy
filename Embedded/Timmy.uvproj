# Keil uVision project Timmy.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Timmy +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, TE_STM32F103_BOARD, STM32F10X_LD
  c include: .\Libraries\CMSIS\Core\CM3;.\inc;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Timmy
    ./src/: hw_config.c led.c main.c servo.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c user_usb.c
  group Headers
    ./inc/: hw_config.h led.h platform_config.h stm32f10x_conf.h stm32f10x_it.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h user_usb.h servo.h
  group USB-FS-Device-Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STDPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group RVMDK
    ./Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
